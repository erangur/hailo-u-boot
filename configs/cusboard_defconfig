## configs/cusboard_defconfig
```kconfig
CONFIG_ARM=y
CONFIG_ARCH_HAILO=y
CONFIG_TARGET_CUSBOARD=y
CONFIG_DEFAULT_DEVICE_TREE="cusboard"
```
